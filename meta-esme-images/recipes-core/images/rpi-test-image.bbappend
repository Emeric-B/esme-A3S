IMAGE_INSTALL += "packagegroup-esme"
