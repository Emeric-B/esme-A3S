# Recipe created by recipetool
# This is the basis of a recipe and may need further editing in order to be fully functional.
# (Feel free to remove these comments when editing.)
DESCRIPTION = "My Custom Package Groups"

inherit packagegroup
# WARNING: the following LICENSE and LIC_FILES_CHKSUM values are best guesses - it is
# your responsibility to verify that the values are complete and correct.
LICENSE = "MIT"
LIC_FILES_CHKSUM = ""

RDEPENDS:${PN} = "esme-gpio-toggle"
# No information for SRC_URI yet (only an external source tree was specified)
SRC_URI = ""



